Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: neo_selene_510_in_under_countertop_basin.ifc
Time: 2017-04-26T11:25:19
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: NEO SELENE 510 In / Under countertop basin
ePset_BIMobject_Lena - LOD: White
ePset_BIMobject_BO - ProductName (BO_prodinfo): NEO SELENE 510 In / Under countertop basin; SKU (BO_prodsku): 322307xx0; ManufacturName (BO_Manufac): Roca; BrandUrl (BO_brandurl): http://www.roca.es; ProductFamily (BO_prodfam): Neo Selene; ProductGroup (BO_prodgroup): Basins; DesignCountry (BO_designcont): Spain; PublishDate (BO_publisdat): 9/26/2016; EditionNumber (BO_edinum): 1; Width (BO_width): 395; Height (BO_height): 180; Depth (BO_depth): 510; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/roca/product/322307xx0; ProductDataUrl (BO_prodaturl): bimobject.com/roca/product/322307xx0; ProductUrl (BO_producturl): http://www.roca.com/catalogue/collections/neo-selene/countertop-countertop-vitreous-china-basin-322307..0; TechnicalDescription (BO_techcert): http://www.roca.com/RocaResourceServlet/resources/getMainResource?idObject={3B31D6D5-21FF-442F-84FF-A63F52992106}; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=68jtjk-3_i4; MaterialMain (BO_mainmat): Vitreous china; BimObjectCategory (BO_bocat): Basins; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L7212; Uniclass14Description (BO_uniclass_1_4_desc): Washbasins; Uniclass20Code (BO_uniclass_2_0_code): SS-35-65-70-94; Uniclass20Description (BO_uniclass_2_0_desc): Wash Basin Systems; NBSReference (BO_nbs_ref): 35-65-70-94; NBSReferenceDescription (BO_nbs_desc): Wash Basin Systems; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
